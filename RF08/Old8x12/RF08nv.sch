# EAGLE board RF08nv (EAGLE 4.11), part 2 of 2
## Tracks (layer width: path | path; a pad name or v marks a point on that pad's centre or on a via) (continued)
DRVOK\  (via drill 0.61) (continued)
  Top 0.254: IC21.13 139.69,77.3 139.69,77.94 R2.1 139.69,79.21 139.69,80.48 141.6,82.38 v141.6,93.81 | v135.25,16.35 136.52,15.08 136.52,8.73 142.24,3.01 196.21,3.01 196.21,13.81 196.84,14.44 v196.84,95.08
  Bottom 0.254: IC21.14 137.79,75.4 139.06,75.4 IC21.13 | v135.25,16.35 126.36,16.35 125.09,15.08 RS08.40 | v196.84,95.08 189.22,95.08 187.96,96.35 182.88,96.35 180.97,98.26 168.91,98.26 167,96.35 162.56,96.35 161.28,95.08 142.87,95.08 v141.6,93.81
EIE  (via drill 0.61)
  Top 0.254: v109.85,136.36 109.85,137 118.11,137 119.38,135.72 119.38,120.48 IC40.9 | v158.11,137 181.61,137 181.61,125.56 182.24,124.93 182.24,116.04 181.61,115.4 177.8,115.4 v177.8,106.52 | v185.41,105.24 186.69,103.97 186.69,90 184.15,87.46 184.15,81.11 182.88,79.84 INTENB.6 183.51,77.94 186.69,74.77 v186.69,57.62 | v145.41,23.96 145.41,33.49 144.14,34.76 IC37.2 | v189.22,23.96 190.5,25.23 190.5,56.98 v189.86,57.62
  Bottom 0.254: v109.85,136.36 111.12,137.63 157.47,137.63 v158.11,137 | v177.8,106.52 179.06,105.24 v185.41,105.24 | v189.22,23.96 v145.41,23.96 | v186.69,57.62 v189.86,57.62
ERROR
  Bottom 0.254: IC12.6 61.59,119.85 62.86,121.12 114.93,121.12 116.2,119.85 IC40.10 117.47,119.85 123.19,125.56 137.16,125.56 138.43,126.83 IC7.2
EXAD0\
  Top 0.254: IC20.9 64.13,16.98 66.04,15.08 66.04,8.09 C35L.34
EXAD1\  (via drill 0.61)
  Top 0.254: v67.94,22.7 68.58,22.06 68.58,8.09 C35L.36
  Bottom 0.254: v67.94,22.7 64.77,22.7 IC20.7
EXAD2\
  Top 0.254: IC20.5 64.13,27.14 66.67,24.6 66.67,8.73 67.31,8.09 67.31,6.82 67.94,6.18 70.48,6.18 70.48,7.46 C35L.38
F.1  (via drill 0.61)
  Top 0.254: 80.01,12.54 80.01,9.36 78.1,9.36 72.39,15.08 IC20.11 | 80.01,12.54 92.07,24.6 92.07,25.87 93.34,27.14 FIELD.3 | v195.58,68.41 194.31,69.68 194.31,81.75 194.94,82.38 v193.67,83.65 | v170.18,83.65 168.91,84.92 168.91,91.91 167,93.81 v167,102.07 | v130.17,100.16 v130.17,81.11 | v109.22,81.11 v109.22,63.34 | v83.81,58.89 82.55,57.62 82.55,29.05 80.01,26.51 80.01,12.54
  Bottom 0.254: v195.58,68.41 201.93,68.41 201.93,32.22 198.75,29.05 191.77,29.05 191.77,24.6 188.59,21.43 187.32,21.43 184.78,18.89 160.02,18.89 158.75,20.16 IC30.8 | v193.67,83.65 192.4,84.92 189.22,84.92 188.59,84.29 170.81,84.29 v170.18,83.65 | v167,102.07 166.37,102.7 140.97,102.7 138.43,100.16 v130.17,100.16 | v130.17,81.11 v109.22,81.11 | v109.22,63.34 104.77,58.89 v83.81,58.89
F.2  (via drill 0.61)  (1 unrouted)
  Top 0.254: v81.91,19.52 83.18,18.25 84.45,18.25 84.45,18.89 90.8,25.23 v90.8,30.32
  Bottom 0.254: v81.91,19.52 81.28,18.89 78.1,18.89 77.47,19.52 73.02,19.52 72.39,20.16 IC20.13 | v90.8,30.32 92.7,30.32 FIELD.2
F.3  (via drill 0.61)
  Top 0.254: v74.29,17.62 73.02,18.89 73.02,23.33 71.75,24.6 IC20.15 | v90.17,17.62 92.7,20.16 FIELD.6
  Bottom 0.254: FIELD.6 95.25,20.16 95.88,20.79 99.69,20.79 100.33,21.43 162.56,21.43 163.83,20.16 IC30.13 | v74.29,17.62 v90.17,17.62
GND  (via drill 0.61)
  Top 0.508: IC41.8 114.3,44.29 113.66,44.92 113.66,48.73 113.03,49.37 113.03,76.67 111.76,77.94 111.76,83.02 IC17.8 | IC32.8 153.03,107.15 154.3,108.42 154.3,112.23 153.03,113.5 IC32.5 151.76,114.77 149.86,116.67 149.86,124.29 147.95,126.2 IC7.15 | IC29.8 165.73,107.15 167,108.42 167,112.23 165.73,113.5 IC29.5 | DAR8-11.8 137.79,84.29 139.06,85.56 139.06,91.91 137.79,93.18 DAR8-11.4 137.79,94.45 139.69,96.35 v139.69,106.52 139.69,110.96 IC7.8 | IC17.15 120.01,99.53 121.92,101.43 121.92,110.32 IC40.7 | 161.92,81.75 160.65,83.02 IC38.13 | 161.92,81.75 161.92,80.48 160.65,79.21 IC38.11 | 161.92,86.83 160.65,88.1 IC38.15 | 161.92,86.83 161.92,81.75 | 161.92,86.83 161.92,91.91 160.65,93.18 IC38.17 | DAR4-7.8 172.08,30.95 170.81,32.22 170.81,38.57 172.08,39.84 DAR4-7.4 | IC24.10 154.94,44.29 156.21,45.55 156.21,53.18 154.94,54.45 IC31.10 154.94,56.98 153.66,58.26 153.66,64.6 153.03,65.24 | 153.03,65.24 150.49,67.78 IC21.8 | 153.03,65.24 153.03,77.94 IC38.10 | INTENB.8 187.96,79.84 187.96,84.92 INTENB.9 187.96,87.46 187.96,92.54 DMA8-11.8 | DMA0-3.4 177.8,67.14 176.53,68.41 176.53,76.03 177.8,77.3 INTENB.4 | IC25.5 179.7,113.5 178.43,112.23 178.43,108.42 179.7,107.15 IC25.8 179.7,105.88 179.06,105.24 179.06,97.62 177.8,96.35 177.8,95.08 DMA8-11.4 | D36L.39 198.12,121.12 198.12,119.85 D36L.37 198.12,118.58 198.12,117.31 D36L.35 198.12,116.04 198.12,114.77 D36L.33 198.12,113.5 198.12,112.23 D36L.31 198.12,110.96 198.12,109.69 D36L.29 198.12,108.42 198.12,107.15 D36L.27 198.12,105.88 198.12,104.61 D36L.25 198.12,103.34 198.12,102.07 D36L.23 198.12,100.8 198.12,99.53 D36L.21 198.12,98.26 198.12,96.99 D36L.19 198.12,95.72 198.12,94.45 D36L.17 198.12,93.18 198.12,91.91 D36L.15 198.12,90.64 198.12,89.37 D36L.13 198.12,88.1 198.12,86.83 D36L.11 198.12,85.56 198.12,84.29 D36L.9 198.12,83.02 198.12,81.75 D36L.7 198.12,80.48 198.12,79.21 D36L.5 198.12,77.94 198.12,76.67 D36L.3 198.12,75.4 198.12,74.13 D36L.1 198.12,72.86 198.12,63.97 C36L.39 198.12,62.7 198.12,61.43 C36L.37 198.12,60.16 198.12,58.89 C36L.35 198.12,57.62 198.12,56.35 C36L.33 198.12,55.08 198.12,53.81 C36L.31 198.12,52.54 198.12,51.27 C36L.29 198.12,50 198.12,48.73 C36L.27 198.12,47.46 198.12,46.19 C36L.25 198.12,44.92 198.12,43.65 C36L.23 198.12,42.38 198.12,41.11 C36L.21 198.12,39.84 198.12,38.57 C36L.19 198.12,37.3 198.12,36.03 C36L.17 198.12,34.76 198.12,33.49 C36L.15 198.12,32.22 198.12,30.95 C36L.13 198.12,29.68 198.12,28.41 C36L.11 198.12,27.14 198.12,25.87 C36L.9 198.12,24.6 198.12,23.33 C36L.7 198.12,22.06 198.12,20.79 C36L.5 198.12,19.52 198.12,18.25 C36L.3 198.12,16.98 198.12,15.71 C36L.1
  Top 0.508: 53.34,91.27 52.06,90 52.06,83.65 53.34,82.38 IC10.2 | 53.34,91.27 53.34,92.54 IC23.2 53.34,95.08 52.06,96.35 52.06,109.05 | 53.34,91.27 55.24,89.37 IC10.12 | 52.06,109.05 53.34,110.32 53.34,112.86 IC9.12 | 52.06,109.05 50.79,107.78 IC9.2 | 64.77,116.67 63.49,117.94 IC12.7 | 64.77,116.67 64.77,111.59 63.49,110.32 63.49,107.78 IC9.7 | IC2.7 23.49,93.18 24.76,93.18 IC2.8 | IC5.7 31.11,116.04 32.38,114.77 32.38,95.72 31.11,94.45 IC6.8 30.48,93.18 30.48,76.67 29.21,75.4 J2.2 | v25.39,118.58 25.39,120.48 IC1.8 | IC3.7 23.49,67.78 24.76,67.78 IC3.8 | IC35.13 46.35,48.73 47.62,50 47.62,51.27 46.35,52.54 IC35.15 | IC13.2 52.7,42.38 51.43,42.38 IC13.1 50.79,44.29 52.06,45.55 52.06,53.18 50.79,54.45 IC14.1 | IC14.13 53.34,62.06 53.34,56.98 IC14.2 | IC13.7 66.04,44.29 67.31,45.55 67.31,51.91 66.04,53.18 66.04,54.45 IC14.7 66.04,56.98 67.31,58.26 67.31,65.88 | 67.31,65.88 66.04,67.14 IC18.7 | 67.31,78.57 66.04,79.84 IC10.7 | 67.31,65.88 67.31,78.57 | 67.31,78.57 67.31,91.27 66.04,92.54 IC23.7 66.04,95.08 66.04,97.62 67.94,99.53 67.94,116.67 64.77,116.67 | J8.2 187.96,29.68 187.96,28.41 J9.2 187.96,27.14 187.96,25.87 J10.2 187.96,24.6 187.96,23.33 J11.2 187.96,22.06 187.96,20.79 J12.2 187.96,19.52 187.96,18.25 J13.2 187.96,16.98 187.96,15.71 J14.2 187.96,14.44 186.69,13.17 186.69,4.92 | D34L.1 142.87,4.92 144.14,4.92 D34L.3 145.41,4.92 146.68,4.92 D34L.5 147.95,4.92 149.22,4.92 D34L.7 | D34L.9 153.03,4.92 154.3,4.92 D34L.11 155.57,4.92 156.84,4.92 D34L.13 158.11,4.92 159.38,4.92 D34L.15 160.65,4.92 161.92,4.92 D34L.17 163.19,4.92 164.46,4.92 D34L.19 165.73,4.92 167,4.92 D34L.21 168.27,4.92 169.54,4.92 D34L.23 170.81,4.92 172.08,4.92 D34L.25 173.35,4.92 174.62,4.92 D34L.27
  Top 0.508: D34L.29 178.43,4.92 179.7,4.92 D34L.31 180.97,4.92 182.24,4.92 D34L.33 183.51,4.92 184.78,4.92 D34L.35 186.05,4.92 186.69,4.92 | 186.69,4.92 187.32,4.92 D34L.37 188.59,4.92 189.86,4.92 D34L.39 | IC20.10 64.13,14.44 64.77,13.81 64.77,6.82 63.49,5.55 C35L.31 | C35L.31 64.13,4.92 65.4,4.92 C35L.33 66.67,4.92 67.94,4.92 C35L.35 69.21,4.92 70.48,4.92 C35L.37 71.75,4.92 73.02,4.92 C35L.39 | IC36.4 15.87,11.9 17.14,11.9 IC36.5 17.78,13.81 19.05,15.08 19.05,23.33 21.59,25.87 21.59,40.48 22.86,41.74 IC4.7 | IC26.10 44.45,14.44 44.45,6.82 43.17,5.55 C35L.15 | C35L.15 43.81,4.92 45.08,4.92 C35L.17 46.35,4.92 47.62,4.92 C35L.19 48.89,4.92 50.16,4.92 C35L.21 51.43,4.92 52.7,4.92 C35L.23 53.97,4.92 55.24,4.92 C35L.25 56.51,4.92 57.78,4.92 C35L.27 59.05,4.92 60.32,4.92 C35L.29 61.59,4.92 62.86,4.92 C35L.31 | C35L.15 42.54,4.92 41.27,4.92 C35L.13 40,4.92 38.73,4.92 C35L.11 37.46,4.92 36.19,4.92 C35L.9 34.92,4.92 33.65,4.92 C35L.7 32.38,4.92 31.11,4.92 C35L.5 29.84,4.92 28.57,4.92 C35L.3 27.3,4.92 26.03,4.92 C35L.1 25.39,5.55 24.12,6.82 24.12,10 25.39,11.27 IC36.8 | C1.2 78.73,20.79 78.73,23.96 IC8.1 | FIELD.4 93.34,24.6 93.34,23.33 FIELD.5 94.61,22.06 95.88,20.79 95.88,16.98 94.61,15.71 FIELD.8 93.34,14.44 90.17,11.27 90.17,4.92 | IC30.10 158.11,15.71 159.38,16.98 159.38,23.33 158.11,24.6 IC30.6 | IC37.10 142.87,15.71 141.6,16.98 141.6,23.33 142.87,24.6 IC37.6 142.87,25.87 139.06,29.68 IC16.15 | D35L.1 84.45,4.92 85.72,4.92 D35L.3 86.99,4.92 88.26,4.92 D35L.5 89.53,4.92 90.17,4.92 | 90.17,4.92 90.8,4.92 D35L.7 | D35L.21 108.58,4.92 107.31,4.92 D35L.19
  Top 0.508: D35L.25 114.93,4.92 116.2,4.92 D35L.27 117.47,4.92 118.11,4.92 | 118.11,4.92 118.74,4.92 D35L.29 | D35L.33 123.82,4.92 122.55,4.92 D35L.31 | D35L.35 127.63,4.92 128.9,4.92 D35L.37 130.17,4.92 130.81,4.92 | 130.81,4.92 131.44,4.92 D35L.39 | 118.11,4.92 118.11,12.54 120.01,14.44 120.01,22.7 121.92,24.6 RS08.31 | 130.81,4.92 130.81,14.44 IC16.8 | IC11.7 85.72,81.75 84.45,83.02 82.55,83.02 82.55,70.95 77.47,65.88 77.47,62.06 78.73,60.8 78.73,56.98 IC15.4
  Bottom 0.508: IC11.7 86.99,81.75 88.9,83.65 110.48,83.65 IC17.8 113.03,83.65 114.3,84.92 125.09,84.92 | IC7.15 146.05,126.83 143.5,126.83 140.97,129.38 IC7.1 | IC29.8 163.83,106.52 162.56,105.24 154.94,105.24 153.66,106.52 IC32.8 151.12,106.52 v139.69,106.52 | 125.09,84.92 125.09,83.65 135.88,83.65 DAR8-11.8 | 125.09,84.92 125.09,85.56 IC22.7 | IC17.1 113.03,101.43 115.56,98.89 118.11,98.89 IC17.15 | 123.19,112.86 124.45,114.13 125.73,114.13 IC19.7 | 123.19,112.86 122.55,112.23 IC40.7 | 123.19,112.86 137.16,112.86 138.43,111.59 IC7.8 | IC38.10 153.66,78.57 158.75,78.57 IC38.11 | IC24.10 155.57,42.38 157.47,40.48 171.44,40.48 DAR4-7.4 | DMA0-3.4 178.43,66.51 179.7,67.78 186.05,67.78 187.32,66.51 DMA0-3.8 | INTENB.4 178.43,77.94 179.7,77.94 INTENB.5 180.97,79.21 182.24,80.48 186.05,80.48 187.32,79.21 INTENB.8 | 179.7,95.72 178.43,94.45 DMA8-11.4 | 179.7,95.72 186.05,95.72 187.32,94.45 DMA8-11.8 188.59,93.18 189.22,92.54 196.21,92.54 197.48,93.81 D36L.17 | DMA4-7.4 178.43,53.81 179.7,55.08 186.05,55.08 187.32,53.81 DMA4-7.8 188.59,53.81 189.22,54.45 196.21,54.45 197.48,55.72 C36L.33 | 179.7,95.72 163.19,95.72 161.28,93.81 IC38.17 | IC9.7 62.86,107.15 61.59,108.42 52.7,108.42 51.43,107.15 IC9.2 | IC1.7 23.49,121.12 24.76,121.12 IC1.8 | IC2.8 26.03,93.81 29.21,93.81 IC6.8 31.75,93.81 33.65,91.91 51.43,91.91 52.7,93.18 IC23.2 | v25.39,118.58 27.3,116.67 29.21,116.67 IC5.7 | 50.79,58.26 46.98,58.26 IC35.17 45.08,58.89 39.36,64.6 29.21,64.6 26.03,67.78 IC3.8 | 50.79,58.26 55.88,58.26 57.78,56.35 IC14.4 59.05,56.35 60.32,57.62 67.94,57.62 | IC4.7 23.49,42.38 24.76,42.38 IC4.8 26.03,43.02 35.55,43.02
  Bottom 0.508: 35.55,43.02 36.82,43.02 IC35.10 | IC14.1 51.43,55.08 52.7,55.08 IC14.2 | IC35.15 46.98,53.18 48.89,55.08 50.16,55.08 IC14.1 | 35.55,43.02 35.55,46.83 39.36,46.83 40.63,48.09 44.45,48.09 IC35.13 | 50.79,58.26 50.79,56.98 IC14.1 | IC15.7 85.72,55.08 84.45,53.81 80.64,53.81 79.37,55.08 IC15.4 78.1,56.35 76.83,57.62 67.94,57.62 | 67.94,57.62 66.67,56.35 IC14.7 | 189.22,31.59 189.22,30.95 187.96,30.95 J8.2 | 189.22,31.59 189.22,33.49 187.96,34.76 J6.2 | D34L.9 151.76,4.92 150.49,4.92 D34L.7 | D34L.29 177.16,4.92 175.89,4.92 D34L.27 | 27.3,14.44 27.94,15.08 29.21,15.08 IC34.10 | 27.3,14.44 26.03,13.17 IC36.8 | 27.3,14.44 19.68,14.44 18.41,13.17 IC36.5 | IC20.17 71.75,29.68 75.56,25.87 78.1,25.87 IC8.1 79.37,24.6 81.28,22.7 92.7,22.7 FIELD.5 | FIELD.8 95.25,15.08 100.33,15.08 FIELD.9 102.87,15.08 107.95,15.08 IC28.10 | IC16.1 132.08,32.86 134.62,30.32 137.16,30.32 IC16.15 | IC30.10 156.21,15.08 154.94,13.81 146.05,13.81 144.78,15.08 IC37.10 142.24,15.08 140.97,13.81 133.34,13.81 132.08,15.08 IC16.8 129.53,15.08 128.27,13.81 123.82,13.81 122.55,15.08 RS08.39 | D35L.7 92.07,4.92 93.34,4.92 D35L.9 94.61,4.92 95.88,4.92 D35L.11 97.15,4.92 98.42,4.92 D35L.13 99.69,4.92 100.96,4.92 D35L.15 102.23,4.92 103.5,4.92 D35L.17 104.77,4.92 106.04,4.92 D35L.19 | D35L.21 109.85,4.92 111.12,4.92 D35L.23 112.39,4.92 113.66,4.92 D35L.25 | D35L.31 121.28,4.92 120.01,4.92 D35L.29 | D35L.35 126.36,4.92 125.09,4.92 D35L.33 | C35L.39 74.29,4.92 83.18,4.92 D35L.1 | D34L.1 141.6,4.92 132.71,4.92 D35L.39 | 189.22,31.59 196.21,31.59 197.48,32.86 C36L.15
INT_RQ\  (via drill 0.61)
  Top 0.254: IC40.8 121.28,118.58 119.38,116.67 119.38,112.86 IC40.6 | v110.48,3.65 110.48,8.09 v107.95,10.63 | v78.73,10.63 75.56,13.81 v75.56,23.96 | v73.02,26.51 73.66,27.14 v73.66,41.74 | v91.44,43.65 90.8,44.29 90.8,102.07 v92.07,103.34 | v111.12,104.61 111.76,105.24 111.76,110.32 IC40.3
  Bottom 0.254: IC40.3 112.39,110.96 113.66,109.69 117.47,109.69 118.74,110.96 IC40.6 | v110.48,3.65 125.09,3.65 125.73,4.28 126.36,3.65 179.06,3.65 179.06,5.55 177.8,6.82 D34L.30 | v78.73,10.63 v107.95,10.63 | v75.56,23.96 v73.02,26.51 | v73.66,41.74 75.56,43.65 v91.44,43.65 | v92.07,103.34 93.34,104.61 v111.12,104.61
IOS\  (1 unrouted)
MYDEV\  (via drill 0.61)
  Top 0.254: v126.36,134.46 v123.19,131.28 | v153.03,133.82 153.03,126.2 154.3,124.93 154.3,118.58 153.03,117.31 IC32.4
  Bottom 0.254: IC32.4 153.66,116.67 157.47,116.67 158.75,115.4 162.56,115.4 163.83,116.67 IC29.4 166.37,116.67 167.63,117.94 173.99,117.94 175.25,116.67 179.06,116.67 IC25.4 | v123.19,131.28 106.04,131.28 103.5,133.82 10.79,133.82 9.52,132.55 1.27,132.55 1.27,32.86 6.98,27.14 22.86,27.14 24.76,25.23 PAD1.1 | v126.36,134.46 152.4,134.46 v153.03,133.82
N$1
  Top 0.254: IC36.9 24.76,20.79 23.49,22.06 23.49,22.7 PAD8.1
N$2
  Bottom 0.254: IC10.8 66.67,89.37 67.94,90.64 76.83,90.64 78.1,89.37 IC11.11
N$3
  Top 0.254: DMA4-7.12 180.34,62.06 180.34,64.6 DMA0-3.5
N$4  (1 unrouted)
  Top 0.254: SW1.1 8.25,105.88 9.52,105.88 SW1.2 10.79,105.88 12.06,105.88 SW1.3 13.33,105.88 14.6,105.88 SW1.4 15.87,105.88 17.14,105.88 SW1.5 18.41,105.88 19.68,105.88 SW1.6 20.95,105.88 22.22,105.88 SW1.7
  Bottom 0.254: SW1.8 24.76,105.88 23.49,105.88 SW1.7
N$5
  Top 0.254: IC36.15 9.52,20.79 8.25,22.06 8.25,22.7 PAD2.1
N$6
  Bottom 0.254: IC36.14 12.06,20.79 10.79,22.06 10.15,22.06 PAD3.1
N$7
  Top 0.254: IC36.13 14.6,20.79 13.33,22.06 13.33,22.7 PAD4.1
N$8
  Top 0.254: IC36.12 17.14,20.79 15.87,22.06 15.87,22.7 PAD5.1
N$9
  Bottom 0.254: IC36.11 19.68,20.79 18.41,22.06 17.78,22.06 PAD6.1
N$10
  Bottom 0.254: IC36.10 22.22,20.79 20.95,22.06 20.32,22.06 PAD7.1
N$11
  Top 0.254: IC36.7 22.86,13.81 26.67,17.62 26.67,22.06 26.03,22.7 PAD9.1
N$12  (via drill 0.61)
  Top 0.254: v74.93,77.3 77.47,79.84 77.47,90 v86.36,98.89 | v177.16,57.62 179.06,55.72 179.06,51.91 178.43,51.27 178.43,44.92 179.7,43.65 DAR4-7.14 | v161.28,56.98 160.02,58.26 160.02,70.95 160.65,71.59 160.65,74.13 v159.38,75.4
  Bottom 0.254: v86.36,98.89 87.62,100.16 113.03,100.16 115.56,97.62 128.27,97.62 130.81,95.08 141.6,95.08 142.87,96.35 143.5,96.35 DAR8-11.14 | IC18.8 66.67,76.67 67.31,77.3 v74.93,77.3 76.83,75.4 99.69,75.4 100.33,76.03 127.63,76.03 130.81,72.86 151.12,72.86 153.03,74.77 158.75,74.77 v159.38,75.4 | v177.16,57.62 170.18,57.62 169.54,56.98 v161.28,56.98
N$13
  Top 0.254: DMA4-7.5 180.34,54.45 179.7,55.08 179.7,58.89 179.06,59.52 179.06,96.35 180.34,97.62 180.34,100.16 DMA8-11.12
N$14  (via drill 0.61)
  Top 0.254: IC13.8 66.04,51.91 64.77,53.18 64.77,60.8 66.04,62.06 IC14.8 | v83.81,51.91 83.81,54.45 IC15.6
  Bottom 0.254: v83.81,51.91 83.18,51.27 66.67,51.27 IC13.8
N$15  (via drill 0.61)
  Top 0.254: v27.3,99.53 28.57,100.8 28.57,107.15 27.94,107.78 27.94,126.83 29.84,128.74 IC5.2
  Bottom 0.254: v27.3,99.53 23.49,99.53 18.41,94.45 IC2.5
N$16  (via drill 0.61)
  Top 0.254: v166.37,71.59 v166.37,78.57 | v138.43,79.84 135.25,83.02 135.25,89.37 136.52,90.64 DAR8-11.5
  Bottom 0.254: v166.37,71.59 178.43,71.59 179.7,72.86 DMA0-3.12 | v166.37,78.57 165.09,79.84 v138.43,79.84
N$17  (1 unrouted)
  Top 0.254: SW2.1 8.25,80.48 9.52,80.48 SW2.2 10.79,80.48 12.06,80.48 SW2.3 13.33,80.48 14.6,80.48 SW2.4 15.87,80.48 17.14,80.48 SW2.5 18.41,80.48 19.68,80.48 SW2.6 20.95,80.48 22.22,80.48 SW2.7 23.49,80.48 24.76,80.48 SW2.8
N$19  (1 unrouted)
  Top 0.254: SW3.1 8.25,55.08 9.52,55.08 SW3.2 10.79,55.08 12.06,55.08 SW3.3 13.33,55.08 14.6,55.08 SW3.4 15.87,55.08 17.14,55.08 SW3.5 | SW3.6 20.95,55.08 22.22,55.08 SW3.7 23.49,55.08 24.76,55.08 SW3.8
  Bottom 0.254: SW3.6 19.68,55.08 18.41,55.08 SW3.5
N$20  (1 unrouted)
  Top 0.254: SW4.1 8.25,28.41 9.52,28.41 SW4.2 | SW4.3 13.33,28.41 14.6,28.41 SW4.4 15.87,28.41 17.14,28.41 SW4.5 18.41,28.41 19.68,28.41 SW4.6
  Bottom 0.254: SW4.3 12.06,28.41 10.79,28.41 SW4.2 | SW4.6 20.95,28.41 22.22,28.41 SW4.7 23.49,28.41 24.76,28.41 SW4.8
N$21  (via drill 0.61)
  Top 0.254: v27.94,70.32 33.02,75.4 33.02,121.75 31.11,123.66 IC5.4
  Bottom 0.254: v27.94,70.32 19.68,70.32 18.41,69.05 IC3.5
N$22  (via drill 0.61)
  Top 0.254: DMA4-7.14 175.25,62.06 173.99,63.34 173.99,69.05 175.25,70.32 175.25,72.22 DMA0-3.14 175.25,74.77 173.99,76.03 173.99,98.89 175.25,100.16 DMA8-11.14 175.89,102.07 175.89,126.2 174.62,127.47 174.62,128.11 v167,128.11 | v66.67,115.4 66.67,112.23 64.77,110.32 64.77,70.95 63.49,69.68 IC18.6 | v154.3,115.4 154.94,116.04 154.94,127.47 v154.3,128.11
  Bottom 0.254: v154.3,115.4 v66.67,115.4 | v154.3,128.11 v167,128.11
N$23
  Top 0.254: IC1.5 17.78,123.02 19.05,124.29 19.05,130.65 20.32,131.92 29.21,131.92 IC5.1
N$24  (via drill 0.61)
  Top 0.254: v5.71,119.21 5.71,53.81 12.06,53.81 13.96,51.91 13.96,48.09 17.78,44.29 IC4.5
  Bottom 0.254: v5.71,119.21 6.34,119.85 27.3,119.85 29.21,121.75 IC5.5
N$25  (via drill 0.61)
  Top 0.254: v145.41,128.11 142.87,125.56 142.87,117.94 142.24,117.31 142.24,112.86 142.87,112.23 142.87,93.18 144.14,91.91 DAR8-11.12 | v194.31,127.47 200.66,121.12 v200.66,41.11
  Bottom 0.254: v145.41,128.11 153.03,128.11 154.3,126.83 167,126.83 167.63,127.47 v194.31,127.47 | v200.66,41.11 198.75,39.2 175.25,39.2 173.99,37.94 DAR4-7.5
N$26  (via drill 0.61)
  Top 0.254: v127.63,100.16 129.53,98.26 129.53,81.75 128.9,81.11 130.17,79.84 v132.71,79.84 | v137.16,78.57 138.43,77.3 138.43,67.14 140.97,64.6 140.97,47.46 138.43,44.92 138.43,35.4 136.52,33.49 136.52,32.22 137.16,31.59 136.52,30.95 136.52,22.06 137.79,20.79 IC16.11
  Bottom 0.254: v127.63,100.16 127,100.16 125.73,101.43 IC22.1 | v132.71,79.84 133.98,78.57 v137.16,78.57
N$27
  Bottom 0.254: IC17.4 113.03,93.81 113.66,94.45 117.47,94.45 118.11,95.08 129.53,95.08 130.81,93.81 IC22.11
N$28  (via drill 0.61)
  Top 0.254: v137.79,128.11 137.79,121.12 139.06,119.85 IC7.5
  Bottom 0.254: v137.79,128.11 129.53,128.11 128.27,129.38 IC19.1
N$29
  Top 0.254: IC8.7 80.64,33.49 80.01,34.12 80.01,41.11 78.73,42.38 78.73,44.92 RA.2
  Bottom 0.254: RB.1 83.18,45.55 81.91,44.29 80.64,44.29 79.37,45.55 RA.2
N$30  (via drill 0.61)
  Top 0.254: IC12.2 50.16,118.58 48.89,118.58 IC12.1 48.25,120.48 49.52,121.75 49.52,128.11 48.89,128.74 44.45,128.74 44.45,67.14 43.17,65.88 v43.17,44.29 | v75.56,34.12 76.2,33.49 76.2,28.41 RL.2
  Bottom 0.254: RL.2 76.83,27.78 77.47,27.14 81.91,27.14 83.18,25.87 IC8.3 | v43.17,44.29 43.17,39.2 64.77,39.2 69.84,34.12 v75.56,34.12
N$31
  Top 0.254: IC18.11 58.41,77.3 59.68,78.57 59.68,86.19 60.95,87.46 IC10.10
N$32
  Top 0.254: RB.2 83.81,34.76 83.81,34.12 IC8.6 83.81,31.59 83.18,30.95 83.18,28.41 81.28,26.51 IC8.2 81.28,23.96 83.81,21.43 83.81,20.79 C1.1
N$33
  Bottom 0.254: IC19.11 135.88,121.75 137.16,120.48 144.14,120.48 145.41,119.21 146.05,119.21 IC7.12
N$34
  Bottom 0.254: IC8.5 86.36,31.59 87.62,30.32 88.26,30.32 C2.2
N$37
  Top 0.254: IC12.11 56.51,126.2 57.78,126.2 IC12.10 59.05,126.2 60.32,126.2 IC12.9
N$40
  Bottom 0.254: IC12.5 58.41,120.48 63.49,125.56 IC12.8
N$53
  Top 0.254: SW1.16 7.62,112.86 8.25,112.23 8.25,111.59 19.05,111.59 19.05,116.67 15.23,120.48 IC1.4
N$54
  Top 0.254: SW1.15 10.15,115.4 12.69,117.94 12.69,120.48 IC1.3
N$55
  Top 0.254: SW1.14 12.69,115.4 13.96,116.67 13.96,123.02 13.33,123.66 10.15,123.66 10.15,123.02 IC1.2
N$56
  Bottom 0.254: IC1.1 6.98,121.12 6.34,120.48 5.71,120.48 4.44,119.21 4.44,116.04 13.33,116.04 14.6,114.77 SW1.13
N$57
  Bottom 0.254: SW1.11 19.68,113.5 17.78,111.59 3.81,111.59 3.81,127.47 10.79,127.47 12.06,128.74 IC1.14
N$58
  Top 0.254: SW1.10 22.22,114.77 16.51,120.48 16.51,126.83 15.23,128.11 IC1.13
N$59
  Bottom 0.254: SW1.9 26.03,114.77 26.67,115.4 31.75,115.4 32.38,116.04 32.38,125.56 21.59,125.56 18.41,128.74 IC1.12
N$60
  Top 0.254: SW1.12 17.14,113.5 15.87,112.23 8.88,112.23 8.88,126.83 10.15,128.11 IC1.15
N$61
  Bottom 0.254: SW2.16 8.25,88.1 9.52,86.83 13.33,86.83 13.96,87.46 13.96,93.18 14.6,93.18 IC2.4
N$62
  Top 0.254: SW2.15 10.15,90 12.69,92.54 IC2.3
N$63
  Bottom 0.254: SW2.14 12.69,90 10.15,92.54 IC2.2
N$64
  Top 0.254: IC2.1 7.62,92.54 8.88,91.27 8.88,87.46 9.52,86.83 14.6,86.83 14.6,88.1 SW2.13
N$65
  Top 0.254: SW2.11 19.68,89.37 16.51,92.54 16.51,96.35 12.69,100.16 IC2.14
N$66
  Top 0.254: SW2.10 22.22,89.37 19.05,92.54 19.05,96.35 15.23,100.16 IC2.13
N$67
  Top 0.254: SW2.9 24.76,89.37 21.59,92.54 21.59,96.35 17.78,100.16 IC2.12
N$68
  Bottom 0.254: SW3.16 8.25,62.7 9.52,61.43 13.33,61.43 13.96,62.06 13.96,67.78 14.6,67.78 IC3.4
N$69
  Top 0.254: SW3.15 10.15,64.6 12.69,67.14 IC3.3
N$70
  Bottom 0.254: SW3.14 12.69,64.6 10.15,67.14 IC3.2
N$71
  Top 0.254: IC3.1 8.25,69.05 9.52,70.32 13.96,70.32 13.96,65.88 15.23,64.6 SW3.13
N$72
  Bottom 0.254: SW3.11 19.68,62.7 17.78,60.8 7.62,60.8 6.34,62.06 6.34,74.13 10.79,74.13 12.06,75.4 IC3.14
N$73
  Top 0.254: SW3.10 22.86,64.6 21.59,65.88 21.59,72.22 19.05,74.77 19.05,77.3 18.41,77.94 15.23,77.94 15.23,77.3 IC3.13
N$74
  Top 0.254: SW3.9 24.76,62.7 23.49,61.43 19.05,61.43 19.05,73.49 17.78,74.77 IC3.12
N$75
  Bottom 0.254: SW4.16 8.25,37.3 12.06,41.11 13.33,41.11 14.6,42.38 IC4.4
N$76
  Top 0.254: SW4.15 10.15,37.94 12.69,40.48 12.69,41.74 IC4.3
N$77
  Top 0.254: SW4.14 12.69,37.94 13.96,39.2 13.96,44.29 13.33,44.92 10.15,44.92 10.15,44.29 IC4.2
N$78
  Top 0.254: IC4.1 7.62,41.74 8.88,40.48 8.88,35.4 9.52,34.76 14.6,34.76 14.6,36.03 SW4.13
N$79
  Top 0.254: SW4.11 20.32,37.94 16.51,41.74 16.51,44.29 12.69,48.09 12.69,49.37 IC4.14
N$80
  Bottom 0.254: SW4.10 22.86,37.94 19.05,41.74 19.05,48.73 17.14,48.73 15.87,50 IC4.13
N$81
  Top 0.254: SW4.9 25.39,37.94 24.12,39.2 24.12,44.29 18.41,50 IC4.12
N$82
  Bottom 0.254: SW4.12 17.78,37.94 17.78,41.11 17.14,41.11 16.51,41.74 16.51,48.09 12.69,48.09 10.79,50 IC4.15
N$83
  Top 0.254: SW3.12 17.78,64.6 16.51,65.88 16.51,72.22 13.96,74.77 13.96,77.3 13.33,77.94 10.15,77.94 10.15,77.3 IC3.15
N$84
  Top 0.254: SW2.12 17.14,89.37 13.96,92.54 13.96,96.35 10.15,100.16 IC2.15
NXD  (1 unrouted)
NXD\
  Top 0.254: IC23.6 63.49,95.08 62.22,96.35 62.22,115.4 59.68,117.94 59.68,120.48 53.97,126.2 IC12.12
PBIT
  Bottom 0.254: IC35.11 46.98,43.02 48.89,44.92 55.24,44.92 59.68,49.37 59.68,53.81 61.59,53.81 62.86,55.08 IC14.6
PCA  (via drill 0.61)
  Top 0.254: v199.38,16.35 201.93,18.89 201.93,124.93 v191.13,135.72 | v118.11,135.72 118.11,114.13 116.84,112.86 IC40.5
  Bottom 0.254: IC40.5 116.2,112.23 114.3,114.13 66.04,114.13 62.86,117.31 57.78,117.31 57.14,117.94 57.14,121.12 55.24,121.12 53.97,119.85 IC12.3 | v199.38,16.35 148.59,16.35 144.78,20.16 IC37.8 | v191.13,135.72 159.38,135.72 158.75,135.09 157.47,135.09 156.21,136.36 118.74,136.36 v118.11,135.72
PER  (1 unrouted)
PER\
  Bottom 0.254: IC12.4 55.88,117.94 57.78,116.04 61.59,116.04 62.86,114.77 IC9.8
PIE  (via drill 0.61)
  Top 0.254: v182.24,31.59 182.24,43.65 181.61,44.29 182.24,44.92 182.24,51.27 181.61,51.91 181.61,56.98 184.15,59.52 v184.15,70.32 | v173.99,70.32 173.99,74.77 172.72,76.03 172.72,77.3 INTENB.2 | v115.56,133.82 115.56,114.13 114.3,112.86 IC40.4
  Bottom 0.254: v182.24,31.59 167.63,31.59 166.37,30.32 IC30.17 | v173.99,70.32 v184.15,70.32 200.66,70.32 200.66,126.2 193.67,133.19 193.03,132.55 182.24,132.55 181.61,131.92 144.78,131.92 144.14,132.55 136.52,132.55 135.88,133.19 116.2,133.19 v115.56,133.82
PROTECT
  Top 0.254: IC6.3 29.84,107.15 28.57,108.42 28.57,117.31 29.84,118.58 IC5.6
SETNXD\  (via drill 0.61)
  Top 0.254: v147.95,87.46 149.86,85.56 149.86,77.3 IC21.9 | v142.87,87.46 142.24,86.83 v142.24,81.75 | v107.95,79.84 107.31,80.48 v107.31,91.27
  Bottom 0.254: v142.87,87.46 v147.95,87.46 | v142.24,81.75 141.6,81.11 131.44,81.11 130.17,79.84 v107.95,79.84 | v107.31,91.27 106.68,91.91 60.32,91.91 59.05,93.18 IC23.4
SETPER\  (via drill 0.61)
  Top 0.254: v69.84,46.19 69.84,65.24 68.58,66.51 68.58,96.99 69.21,97.62 v69.21,111.59
  Bottom 0.254: v69.84,46.19 64.13,46.19 61.59,43.65 IC13.5 | v69.21,111.59 68.58,112.23 60.32,112.23 59.05,113.5 IC9.10
SETWLS\
  Bottom 0.254: IC6.7 31.11,96.99 36.82,102.7 49.52,102.7 51.43,104.61 53.97,104.61 55.24,105.88 IC9.4
SKIP\  (via drill 0.61)
  Top 0.254: IC19.2 126.36,126.2 125.09,124.93 125.09,118.58 126.36,117.31 IC19.6 125.73,116.67 120.65,116.67 120.65,107.78 112.39,99.53 IC17.2 | v94.61,98.89 v94.61,36.03
  Bottom 0.254: IC19.6 128.27,116.67 130.81,119.21 133.34,119.21 IC19.10 | v94.61,36.03 93.98,36.66 83.18,36.66 81.91,35.4 R1.1 | v94.61,98.89 110.48,98.89 IC17.2
START\  (1 unrouted)
  Top 0.254: 181.61,70.95 181.61,63.34 182.88,62.06 DMA4-7.11 | 181.61,70.95 182.88,72.22 DMA0-3.11 | 181.61,70.95 181.61,95.08 182.24,95.72 182.24,99.53 182.88,100.16 DMA8-11.11
VCC  (via drill 0.61)
  Top 0.508: v187.32,49.37 187.96,48.73 187.96,46.19 J3.2 187.96,44.92 187.96,43.65 J4.2 187.96,42.38 187.96,41.11 J5.2 187.96,39.84 186.69,38.57 186.69,34.76 187.96,33.49 J7.2 | DMA4-7.16 170.18,62.06 168.91,63.34 168.91,70.95 170.18,72.22 DMA0-3.16 170.18,74.77 168.91,76.03 168.91,81.75 v169.54,82.38 | R2.2 130.17,78.57 130.17,77.94 131.44,76.67 IC21.16 132.08,74.77 130.81,73.49 130.81,60.8 | 130.81,60.8 130.81,53.18 132.08,51.91 IC24.20 132.08,49.37 130.81,48.09 130.81,37.94 v132.08,36.66 | 130.81,60.8 132.08,62.06 IC31.20 | v151.12,40.48 151.12,38.57 IC37.20 | 170.81,107.78 170.18,107.78 170.18,102.7 DMA8-11.16 | 170.81,107.78 173.99,107.78 174.62,107.15 174.62,103.97 173.99,103.34 173.99,100.16 171.44,97.62 171.44,92.54 170.81,91.91 170.81,88.1 170.18,87.46 INTENB.16 | 170.81,107.78 170.81,122.39 172.08,123.66 IC29.16 | v157.47,129.38 157.47,126.83 159.38,124.93 IC32.16 | v113.03,104.61 113.03,112.86 107.31,118.58 IC40.14 | v144.14,107.78 144.14,102.07 DAR8-11.16 | 132.71,102.07 v138.43,107.78 | 132.71,102.07 IC22.14 132.71,102.07 | 132.71,102.07 132.71,127.47 133.98,128.74 IC19.14 | IC2.16 7.62,100.16 6.34,98.89 6.34,78.57 7.62,77.3 IC3.16 | IC36.16 6.98,20.79 6.34,21.43 6.34,48.09 7.62,49.37 IC4.16 | IC8.4 86.99,25.23 88.26,25.23 C2.1 | v81.28,37.94 81.28,44.92 R1.2 | RL.1 76.2,38.57 76.2,54.45 IC15.3 76.2,56.98 75.56,57.62 75.56,61.43 74.93,62.06 74.93,75.4 78.73,79.21 78.73,79.84 IC11.4 78.73,82.38 81.28,84.92 81.28,87.46 IC11.10 | v78.73,37.94 78.73,36.03 RA.1 78.73,34.76 78.73,34.12 IC8.8 78.73,31.59 78.73,29.05 v79.37,28.41 | IC13.3 55.88,44.29 57.14,45.55 57.14,51.91 55.88,53.18 55.88,54.45 IC14.3
  Top 0.508: IC26.20 51.43,38.57 49.52,40.48 49.52,48.09 50.79,49.37 IC13.14 50.79,51.91 49.52,53.18 49.52,58.89 50.79,60.16 50.79,62.06 IC14.14 50.79,64.6 52.06,65.88 52.06,73.49 | 51.43,90.64 52.06,91.27 52.06,95.08 50.79,96.35 50.79,100.16 IC23.14 | 51.43,90.64 50.79,90 IC10.14 50.79,87.46 50.79,83.65 52.06,82.38 52.06,73.49 | 52.06,73.49 50.79,74.77 IC18.14 | IC11.14 71.12,87.46 69.84,86.19 69.84,66.51 71.12,65.24 71.12,64.6 IC15.14 | 51.43,90.64 46.98,95.08 46.98,111.59 48.25,112.86 IC9.14
  Bottom 0.508: v187.32,49.37 182.88,49.37 181.61,48.09 DAR4-7.16 | J7.2 187.32,32.86 186.05,34.12 179.06,34.12 176.53,36.66 167.63,36.66 166.37,37.94 IC30.20 163.83,37.94 162.56,39.2 156.21,39.2 155.57,39.84 151.76,39.84 v151.12,40.48 | 139.06,36.66 139.06,33.49 IC16.16 | 139.06,36.66 145.41,36.66 146.68,37.94 149.86,37.94 IC37.20 | IC31.20 131.44,63.34 125.09,63.34 RS08.2 124.45,62.7 127,60.16 128.27,60.16 128.9,60.8 148.59,60.8 149.22,61.43 169.54,61.43 DMA4-7.16 | v132.08,36.66 139.06,36.66 | IC38.20 161.28,101.43 161.92,100.8 169.54,100.8 DMA8-11.16 | IC29.16 173.99,124.29 177.8,124.29 179.06,123.02 185.41,123.02 186.69,124.29 IC25.16 189.22,124.29 191.13,126.2 194.94,126.2 195.58,126.83 195.58,129.38 v157.47,129.38 148.59,129.38 IC7.16 146.05,129.38 142.24,129.38 140.97,130.65 137.16,130.65 135.88,129.38 IC19.14 133.34,129.38 132.08,130.65 125.73,130.65 124.45,129.38 45.71,129.38 | IC22.14 130.81,101.43 128.9,103.34 122.55,103.34 120.65,101.43 IC17.16 118.11,101.43 116.2,101.43 v113.03,104.61 | v138.43,107.78 v144.14,107.78 | v169.54,82.38 168.91,83.02 168.91,85.56 169.54,85.56 INTENB.16 | IC36.6 19.68,11.9 18.41,10.63 12.06,10.63 11.42,11.27 11.42,18.25 9.52,18.25 8.25,19.52 IC36.16 | IC4.16 7.62,51.91 5.71,53.81 5.71,75.4 6.98,75.4 IC3.16 | IC28.20 115.56,37.94 112.39,37.94 111.12,36.66 106.68,36.66 102.87,32.86 FIELD.16 101.59,33.49 101.59,37.94 v81.28,37.94 v78.73,37.94 76.83,37.94 RL.1 75.56,37.94 72.39,37.94 IC20.20 | v79.37,28.41 83.18,28.41 85.72,25.87 IC8.4 | IC34.20 39.36,37.94 40.63,36.66 49.52,36.66 50.79,37.94 IC26.20
  Bottom 0.508: IC13.14 51.43,51.27 55.24,55.08 IC14.3 | IC41.16 95.88,50 94.61,48.73 61.59,48.73 56.51,43.65 IC13.3 | 43.81,113.5 47.62,113.5 IC9.14 | 43.81,113.5 41.27,113.5 39.36,111.59 IC6.16 | 45.71,129.38 43.17,131.92 39.36,131.92 IC5.14 36.82,131.92 35.55,133.19 11.42,133.19 8.25,130.01 IC1.16 6.98,128.74 3.17,128.74 3.17,107.15 7.62,102.7 IC2.16 | 45.71,129.38 47.62,127.47 IC12.14 47.62,126.2 43.81,126.2 43.81,113.5 | IC11.4 78.1,81.75 73.66,86.19 53.34,86.19 51.43,88.1 IC10.14 | IC35.20 46.98,65.88 48.89,63.97 50.16,63.97 IC14.14 51.43,62.7 52.7,61.43 69.21,61.43 70.48,62.7 IC15.14
WE\
  Top 0.254: IC22.5 123.82,90.64 122.55,89.37 122.55,66.51 123.19,65.88 123.19,57.62 124.45,56.35 RS08.8
  Bottom 0.254: IC6.5 29.84,100.8 28.57,99.53 28.57,95.08 49.52,95.08 50.79,96.35 106.04,96.35 109.85,92.54 120.65,92.54 121.92,91.27 123.19,91.27 IC22.5
WLS  (1 unrouted)
WLS\
  Top 0.254: IC9.6 60.95,107.78 57.14,111.59 57.14,120.48 51.43,126.2 IC12.13
WRITING  (via drill 0.61)
  Top 0.254: v101.59,79.21 101.59,51.91 IC41.14 | v60.95,97.62 61.59,96.99 61.59,95.72 62.22,95.08 62.22,83.65 60.95,82.38 IC10.5 | v120.65,51.91 120.65,49.37 122.55,49.37 123.19,48.73 123.19,44.92 124.45,43.65 RS08.18
  Bottom 0.254: v101.59,79.21 62.86,79.21 61.59,80.48 IC10.5 | v60.95,97.62 64.77,97.62 64.77,107.78 63.49,109.05 48.25,109.05 46.98,107.78 33.02,107.78 31.75,109.05 IC6.2 | IC41.14 102.23,50 103.5,50 IC41.13 104.77,51.27 106.04,52.54 120.01,52.54 v120.65,51.91

## Text on the board
Bottom: RF08 | VRS
tPlace: RF08 | VRS